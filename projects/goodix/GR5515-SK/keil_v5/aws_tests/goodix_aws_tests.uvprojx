# Keil uVision project goodix_aws_tests.uvprojx, settings and files
target aws_tests (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: goodix_aws_tests +hex
  AfterMake: ..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\build\scripts\after_build.bat  @L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GR5515_SK __CHECK_DEVICE_DEFINES __little_endian__=1 AMAZON_FREERTOS_ENABLE_UNIT_TESTS
  c include: ..\..\..\..\..\freertos_kernel\;..\..\..\..\..\freertos_kernel\include;..\..\..\..\..\freertos_kernel\portable\RVDS\GR5515-SK;..\..\..\..\..\tools\cbmc\windows;..\..\..\..\..\libraries\3rdparty\jsmn;..\..\..\..\..\libraries\3rdparty\mbedtls\include\;..\..\..\..\..\libraries\3rdparty\mbedtls\include\mbedtls;..\..\..\..\..\libraries\3rdparty\pkcs11;..\..\..\..\..\libraries\3rdparty\tinycbor;..\..\..\..\..\libraries\3rdparty\unity\src;..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src;..\..\..\..\..\libraries\3rdparty\tinycrypt\lib\include;..\..\..\..\..\libraries\3rdparty\tinycrypt\lib\include\tinycrypt;..\..\..\..\..\libraries\3rdparty\tinycrypt\asn1;..\..\..\..\..\libraries\abstractions\ble_hal\include;..\..\..\..\..\libraries\abstractions\pkcs11;..\..\..\..\..\libraries\abstractions\pkcs11\include;..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls;..\..\..\..\..\libraries\abstractions\pkcs11\test;..\..\..\..\..\libraries\abstractions\platform\include;..\..\..\..\..\libraries\abstractions\platform\include\platform;..\..\..\..\..\libraries\abstractions\platform\include\types;..\..\..\..\..\libraries\abstractions\platform\freertos;..\..\..\..\..\libraries\abstractions\platform\freertos\include;..\..\..\..\..\libraries\abstractions\platform\freertos\include\platform;..\..\..\..\..\libraries\abstractions\posix\include\;..\..\..\..\..\libraries\abstractions\posix\include\FreeRTOS_POSIX;..\..\..\..\..\libraries\abstractions\posix\include\FreeRTOS_POSIX\sys;..\..\..\..\..\libraries\abstractions\secure_sockets\include;..\..\..\..\..\libraries\c_sdk\aws\defender\include\;..\..\..\..\..\libraries\c_sdk\aws\defender\src\private;..\..\..\..\..\libraries\c_sdk\aws\shadow\include;..\..\..\..\..\libraries\c_sdk\aws\shadow\include\types;..\..\..\..\..\libraries\c_sdk\aws\shadow\src;..\..\..\..\..\libraries\c_sdk\aws\shadow\src\private;..\..\..\..\..\libraries\c_sdk\standard\ble\src;..\..\..\..\..\libraries\c_sdk\standard\ble\include;..\..\..\..\..\libraries\c_sdk\standard\common\include;..\..\..\..\..\libraries\c_sdk\standard\common\include\private;..\..\..\..\..\libraries\c_sdk\standard\common\include\types;..\..\..\..\..\libraries\c_sdk\standard\mqtt;..\..\..\..\..\libraries\c_sdk\standard\mqtt\include;..\..\..\..\..\libraries\c_sdk\standard\mqtt\include\types;..\..\..\..\..\libraries\c_sdk\standard\mqtt\src;..\..\..\..\..\libraries\c_sdk\standard\mqtt\src\private;..\..\..\..\..\libraries\c_sdk\standard\mqtt\test\access;..\..\..\..\..\libraries\c_sdk\standard\serializer\include;..\..\..\..\..\libraries\freertos_plus\aws\ota;..\..\..\..\..\libraries\freertos_plus\aws\ota\include;..\..\..\..\..\libraries\freertos_plus\aws\ota\src;..\..\..\..\..\libraries\freertos_plus\standard\freertos_plus_posix\include;..\..\..\..\..\libraries\freertos_plus\standard\utils\include;..\..\..\..\..\libraries\freertos_plus\standard\crypto\include;..\..\..\..\..\libraries\freertos_plus\standard\tls\include;..\..\..\..\..\demos\network_manager;..\..\..\..\..\demos\dev_mode_key_provisioning;..\..\..\..\..\demos\dev_mode_key_provisioning\include;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\build\config;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\app_drivers\inc;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\boards;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\drivers_ext\gr551x;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\sdk;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\app_assert;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\app_error;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\app_key;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\app_log;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\app_timer;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\at_cmd;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\bsp;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\gui;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\gui\gui_config;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\hal_flash;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\hal_flash\vflash;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\hci_uart;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\log;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\pmu_calibration;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\pwr_mgmt;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\ring_buffer;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\sensorsim;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\libraries\utility;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\patch\ind;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\profiles\common;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\drivers\inc;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\external\segger_rtt;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\toolchain\gr551x\include;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\toolchain\gr551x\source\arm;..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\toolchain\cmsis\include;..\..\..\..\..\vendors\goodix\boards\GR5515-SK\ports\ble;..\..\..\..\..\vendors\goodix\boards\GR5515-SK\ports\ble\user_callback;..\..\..\..\..\vendors\goodix\boards\GR5515-SK\ports\posix;..\..\..\..\..\vendors\goodix\boards\GR5515-SK\ports\ota;..\..\..\..\..\libraries\freertos_plus\aws\ota\test;..\..\..\..\..\libraries\freertos_plus\aws\ota\test\test_files;..\..\..\..\..\vendors\goodix\boards\GR5515-SK\aws_tests;..\..\..\..\..\vendors\goodix\boards\GR5515-SK\aws_tests\application_code;..\..\..\..\..\vendors\goodix\boards\GR5515-SK\aws_tests\application_code\goodix_code;..\..\..\..\..\vendors\goodix\boards\GR5515-SK\aws_tests\config_files;..\..\..\..\..\tests;..\..\..\..\..\tests\include
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\toolchain\gr551x\source\arm\flash_scatter_common.sct
  link misc: ..\..\..\..\..\vendors\goodix\GR551x_SDK_V1_00\components\patch\symbol_table\rom_symbol.txt  --diag_suppress=6314  --diag_suppress=6329  --diag_suppress=6319
  group application
    ../../../../../vendors/goodix/boards/GR5515-SK/aws_tests/application_code/: main.c
    ../../../../../vendors/goodix/boards/GR5515-SK/aws_tests/application_code/goodix_code/: user_periph_setup.c user_periph_setup.h
  group application/gr5515-sk/aws_tests/config_files
    ../../../../../vendors/goodix/boards/GR5515-SK/aws_tests/config_files/: aws_bufferpool_config.h aws_ggd_config.h aws_mqtt_config.h aws_ota_agent_config.h aws_pkcs11_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h trcConfig.h trcSnapshotConfig.h aws_mqtt_agent_config.h iot_ble_config.h aws_test_runner_config.h
  group application/tests/include
    ../../../../../tests/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_test_framework.h aws_test_runner.h aws_test_tcp.h aws_test_utils.h aws_unity_config.h iot_config_common.h
  group application/tests/common
    ../../../../../tests/common/: aws_test.c aws_test_framework.c aws_test_runner.c iot_test_afr.c iot_tests_network.c
  group application/tests/pkcs11
    ../../../../../libraries/abstractions/pkcs11/test/: aws_test_pkcs11.c
  group application/tests/ble
    ../../../../../libraries/abstractions/ble_hal/test/: aws_test_ble_hal.c
    ../../../../../libraries/c_sdk/standard/ble/test/: aws_test_ble_end_to_end.c
  group application/tests/memory
    ../../../../../libraries/c_sdk/standard/common/test/: aws_memory_leak.c
  group application/tests/posix
    ../../../../../libraries/freertos_plus/standard/freertos_plus_posix/test/: aws_test_posix_clock.c aws_test_posix_mqueue.c aws_test_posix_pthread.c aws_test_posix_semaphore.c aws_test_posix_stress.c aws_test_posix_timer.c aws_test_posix_unistd.c aws_test_posix_utils.c
  group application/tests/serializer
    ../../../../../libraries/c_sdk/standard/serializer/test/: iot_tests_serializer_cbor.c iot_tests_serializer_json.c
  group application/tests/shadow
    ../../../../../libraries/c_sdk/aws/shadow/test/: aws_test_shadow.c
    ../../../../../libraries/c_sdk/aws/shadow/test/system/: aws_iot_tests_shadow_system.c
    ../../../../../libraries/c_sdk/aws/shadow/test/unit/: aws_iot_tests_shadow_api.c aws_iot_tests_shadow_parser.c
  group application/tests/mqtt
    ../../../../../libraries/c_sdk/standard/mqtt/test/access/: iot_test_access_mqtt.h
    ../../../../../libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/unit/: aws_iot_tests_mqtt_serialize_ble.c iot_tests_mqtt_api.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c
  group application/tests/crypto
    ../../../../../libraries/freertos_plus/standard/crypto/test/: aws_test_crypto.c
  group application/tests/ota
    ../../../../../libraries/freertos_plus/aws/ota/test/: aws_ota_agent_test_access_declare.h aws_ota_agent_test_access_define.h aws_ota_codesigner_certificate.h aws_ota_pal_test_access_declare.h aws_ota_pal_test_access_define.h aws_test_ota_end_to_end.c aws_test_ota_pal.c aws_test_ota_pal_ecdsa_sha256_signature.h aws_test_ota_pal_rsa_sha1_signature.h aws_test_ota_pal_rsa_sha256_signature.h aws_test_ota_signature_methods.h aws_test_ota_agent.c
  group demos/dev_mode_key_provisioning
    ../../../../../demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c pem2der.c
  group freertos_kernel/portable
    ../../../../../freertos_kernel/portable/RVDS/GR5515-SK/: port.c port_pm.c portmacro.h
  group freertos_kernel/inc
    ../../../../../freertos_kernel/include/: atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group freertos_kernel/src
    ../../../../../freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_kernel/heap
    ../../../../../freertos_kernel/portable/MemMang/: heap_4.c
  group libraries/3rdparty/unity/
    ../../../../../libraries/3rdparty/unity/src/: unity.c unity.h unity_internals.h
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group libraries/3rdparty/mbedtls/inc
    ../../../../../libraries/3rdparty/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs12.h platform.h platform_time.h platform_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group libraries/3rdparty/mbedtls/src
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group libraries/3rdparty/pkcs11
    ../../../../../libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group libraries/3rdparty/tinycbor
    ../../../../../libraries/3rdparty/tinycbor/: assert_p.h cbor.h cborconstants_p.h cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c compilersupport_p.h extract_number_p.h math_support_p.h
  group libraries/3rdparty/tinycrypt
    ../../../../../libraries/3rdparty/tinycrypt/asn1/: asn1.h asn1parse.c
    ../../../../../libraries/3rdparty/tinycrypt/lib/source/: aes_decrypt.c aes_encrypt.c cbc_mode.c ccm_mode.c cmac_mode.c ctr_mode.c ctr_prng.c ecc.c ecc_dh.c ecc_dsa.c ecc_platform_specific.c hmac.c hmac_prng.c sha256.c utils.c
  group libraries/3rdparty/jsmn
    ../../../../../libraries/3rdparty/jsmn/: jsmn.c jsmn.h
  group libraries/abstractions/ble_hal/include
    ../../../../../libraries/abstractions/ble_hal/include/: bt_hal_avsrc_profile.h bt_hal_gatt_client.h bt_hal_gatt_server.h bt_hal_gatt_types.h bt_hal_manager.h bt_hal_manager_adapter_ble.h bt_hal_manager_adapter_classic.h bt_hal_manager_types.h
  group libraries/abstractions/platform/include/platform/
    ../../../../../libraries/abstractions/platform/include/platform/: iot_clock.h iot_network.h iot_threads.h iot_metrics.h
  group libraries/abstractions/platform/include/types/
    ../../../../../libraries/abstractions/platform/include/types/: iot_platform_types.h
  group libraries/abstractions/platform/freertos/
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_afr.c iot_threads_afr.c iot_metrics.c
  group libraries/abstractions/platform/freertos/include/platform/
    ../../../../../libraries/abstractions/platform/freertos/include/platform/: iot_platform_types_afr.h iot_network_afr.h
  group libraries/abstractions/posix/include/FreeRTOS_POSIX
    ../../../../../libraries/abstractions/posix/include/FreeRTOS_POSIX/: errno.h fcntl.h mqueue.h pthread.h sched.h semaphore.h signal.h time.h unistd.h utils.h
  group libraries/abstractions/posix/include/FreeRTOS_POSIX/sys
    ../../../../../libraries/abstractions/posix/include/FreeRTOS_POSIX/sys/: types.h
  group libraries/abstractions/pkcs11/include
    ../../../../../libraries/abstractions/pkcs11/include/: aws_pkcs11.h
  group libraries/abstractions/pkcs11/mbedtls
    ../../../../../libraries/abstractions/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c threading_alt.h
  group libraries/c_sdk/aws/shadow
    ../../../../../libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c aws_shadow_config_defaults.h
    ../../../../../libraries/c_sdk/aws/shadow/src/private/: aws_iot_shadow_internal.h
  group libraries/c_sdk/standard/ble/include
    ../../../../../libraries/c_sdk/standard/ble/include/: iot_ble.h iot_ble_config_defaults.h iot_ble_data_transfer.h iot_ble_device_information.h iot_ble_mqtt_serialize.h iot_ble_wifi_provisioning.h
  group libraries/c_sdk/standard/ble/src
    ../../../../../libraries/c_sdk/standard/ble/src/: iot_ble_gap.c iot_ble_gatt.c iot_ble_internal.h
  group libraries/c_sdk/standard/ble/src/services/device_information
    ../../../../../libraries/c_sdk/standard/ble/src/services/device_information/: iot_ble_device_information.c
  group libraries/c_sdk/standard/ble/src/services/mqtt_ble
    ../../../../../libraries/c_sdk/standard/ble/src/services/mqtt_ble/: iot_ble_data_transfer.c iot_network_ble.c
  group libraries/c_sdk/standard/common/include
    ../../../../../libraries/c_sdk/standard/common/include/: aws_appversion32.h aws_logging_task.h iot_atomic.h iot_init.h iot_linear_containers.h iot_logging_setup.h iot_taskpool.h
  group libraries/c_sdk/standard/common/logging
    ../../../../../libraries/c_sdk/standard/common/logging/: aws_logging_task_dynamic_buffers.c iot_logging.c
  group libraries/c_sdk/standard/common/taskpool
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries/c_sdk/standard/common
    ../../../../../libraries/c_sdk/standard/common/: iot_init.c iot_static_memory_common.c
  group libraries/c_sdk/standard/mqtt/inc
    ../../../../../libraries/c_sdk/standard/mqtt/include/: aws_mqtt_agent.h aws_mqtt_agent_config_defaults.h aws_mqtt_config_defaults.h aws_mqtt_lib.h iot_mqtt.h
    ../../../../../libraries/c_sdk/standard/mqtt/include/types/: iot_mqtt_types.h
  group libraries/c_sdk/standard/mqtt/src
    ../../../../../libraries/c_sdk/standard/mqtt/src/private/: iot_mqtt_internal.h
    ../../../../../libraries/c_sdk/standard/mqtt/src/: iot_ble_mqtt_serialize.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c aws_mqtt_agent.c
  group libraries/c_sdk/standard/serializer/inc
    ../../../../../libraries/c_sdk/standard/serializer/include/: iot_json_utils.h iot_serializer.h
  group libraries/c_sdk/standard/serializer/src
    ../../../../../libraries/c_sdk/standard/serializer/src/: iot_json_utils.c iot_serializer_static_memory.c
    ../../../../../libraries/c_sdk/standard/serializer/src/cbor/: iot_serializer_tinycbor_decoder.c iot_serializer_tinycbor_encoder.c
    ../../../../../libraries/c_sdk/standard/serializer/src/json/: aws_iot_serializer_json_decoder.c aws_iot_serializer_json_encoder.c
  group libraries/freertos_plus/aws/ota
    ../../../../../libraries/freertos_plus/aws/ota/src/: aws_iot_ota_agent.c aws_ota_agent_internal.h aws_ota_cbor.c aws_ota_cbor.h aws_ota_cbor_internal.h aws_ota_pal.h
  group libraries/freertos_plus/standard/freertos_plus_posix/inc
    ../../../../../libraries/freertos_plus/standard/freertos_plus_posix/include/: FreeRTOS_POSIX.h FreeRTOS_POSIX_internal.h FreeRTOS_POSIX_portable_default.h FreeRTOS_POSIX_types.h
  group libraries/freertos_plus/standard/freertos_plus_posix/src
    ../../../../../libraries/freertos_plus/standard/freertos_plus_posix/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group libraries/freertos_plus/standard/crypto
    ../../../../../libraries/freertos_plus/standard/crypto/include/: aws_crypto.h
    ../../../../../libraries/freertos_plus/standard/crypto/src/: aws_crypto.c
  group libraries/freertos_plus/standard/tls
    ../../../../../libraries/freertos_plus/standard/tls/include/: aws_tls.h
    ../../../../../libraries/freertos_plus/standard/tls/src/: aws_tls.c
  group libraries/freertos_plus/standard/utils
    ../../../../../libraries/freertos_plus/standard/utils/include/: aws_system_init.h
  group gr5515-sk/lib
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/sdk/linker/lib/: ble_sdk.lib
  group gr5515-sk/startup
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/toolchain/gr551x/source/arm/: startup_gr55xx.s
  group gr5515-sk/system
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/toolchain/gr551x/source/: system_gr55xx.c interrupt_gr55xx.c platform_gr55xx.c
  group gr5515-sk/app_drivers/inc
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/app_drivers/inc/: app_adc.h app_aes.h app_comp.h app_dma.h app_drv_error.h app_dual_tim.h app_gpiote.h app_hmac.h app_i2c.h app_i2s.h app_io.h app_pwr_mgmt.h app_qspi.h app_rng.h app_spi.h app_systick.h app_tim.h app_uart.h
  group gr5515-sk/app_drivers/src
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/app_drivers/src/: app_adc.c app_aes.c app_comp.c app_dma.c app_dual_tim.c app_gpiote.c app_hmac.c app_i2c.c app_i2s.c app_io.c app_pwr_mgmt.c app_qspi.c app_rng.c app_spi.c app_systick.c app_tim.c app_uart.c
  group gr5515-sk/drivers/inc
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/drivers/inc/: gr55xx_delay.h gr55xx_hal.h gr55xx_hal_adc.h gr55xx_hal_aes.h gr55xx_hal_aon_gpio.h gr55xx_hal_aon_gpio_ex.h gr55xx_hal_aon_wdt.h gr55xx_hal_calendar.h gr55xx_hal_cgc.h gr55xx_hal_conf.h gr55xx_hal_cortex.h gr55xx_hal_def.h gr55xx_hal_dma.h gr55xx_hal_dual_tim.h gr55xx_hal_efuse.h gr55xx_hal_exflash.h gr55xx_hal_gpio.h gr55xx_hal_gpio_ex.h gr55xx_hal_hmac.h gr55xx_hal_i2c.h gr55xx_hal_i2s.h gr55xx_hal_msio.h gr55xx_hal_msio_ex.h gr55xx_hal_pkc.h gr55xx_hal_pwm.h gr55xx_hal_pwr.h gr55xx_hal_qspi.h gr55xx_hal_rng.h gr55xx_hal_spi.h gr55xx_hal_tim.h gr55xx_hal_uart.h gr55xx_hal_wdt.h gr55xx_hal_xqspi.h gr55xx_ll_adc.h gr55xx_ll_aes.h gr55xx_ll_aon_gpio.h gr55xx_ll_aon_wdt.h gr55xx_ll_calendar.h gr55xx_ll_cgc.h gr55xx_ll_dma.h gr55xx_ll_dual_tim.h gr55xx_ll_efuse.h gr55xx_ll_gpio.h gr55xx_ll_hmac.h gr55xx_ll_i2c.h gr55xx_ll_i2s.h gr55xx_ll_iso7816.h gr55xx_ll_msio.h gr55xx_ll_pkc.h gr55xx_ll_pwm.h gr55xx_ll_pwr.h gr55xx_ll_rng.h gr55xx_ll_spi.h gr55xx_ll_tim.h gr55xx_ll_uart.h gr55xx_ll_wdt.h gr55xx_ll_xqspi.h gr55xx_hal_comp.h gr55xx_ll_comp.h
  group gr5515-sk/drivers/src
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/drivers/src/: gr55xx_hal.c gr55xx_hal_adc.c gr55xx_hal_aes.c gr55xx_hal_aon_gpio.c gr55xx_hal_aon_wdt.c gr55xx_hal_calendar.c gr55xx_hal_dual_tim.c gr55xx_hal_efuse.c gr55xx_hal_exflash.c gr55xx_hal_gpio.c gr55xx_hal_hmac.c gr55xx_hal_i2c.c gr55xx_hal_i2s.c gr55xx_hal_pkc.c gr55xx_hal_pwm.c gr55xx_hal_pwr.c gr55xx_hal_qspi.c gr55xx_hal_rng.c gr55xx_hal_spi.c gr55xx_hal_tim.c gr55xx_hal_uart.c gr55xx_hal_wdt.c gr55xx_hal_xqspi.c gr55xx_hal_cgc.c gr55xx_hal_comp.c gr55xx_hal_cortex.c gr55xx_hal_dma.c gr55xx_hal_msio.c gr55xx_hal_msp_template.c gr55xx_hal_utils.c gr55xx_ll_adc.c gr55xx_ll_aes.c gr55xx_ll_aon_gpio.c gr55xx_ll_cgc.c gr55xx_ll_comp.c gr55xx_ll_dma.c gr55xx_ll_dual_tim.c gr55xx_ll_gpio.c gr55xx_ll_hmac.c gr55xx_ll_i2c.c gr55xx_ll_i2s.c gr55xx_ll_msio.c gr55xx_ll_pkc.c gr55xx_ll_pwm.c gr55xx_ll_rng.c gr55xx_ll_spi.c gr55xx_ll_tim.c gr55xx_ll_uart.c gr55xx_ll_xqspi.c
  group gr5515-sk/drivers/ext
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/drivers_ext/gr551x/: gr551x_spi_flash.c gr551x_spi_flash.h gr551x_temp_api.c gr551x_temp_api.h gr551x_tim_delay.c gr551x_tim_delay.h gr551x_vbat_api.c gr551x_vbat_api.h gr551x_adc_voltage_api.c gr551x_adc_voltage_api.h
  group gr5515-sk/library/flash
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/libraries/hal_flash/: hal_flash.c hal_flash.h
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/libraries/hal_flash/vflash/: vflash.c vflash.h
  group gr5515-sk/library/app_timer
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/libraries/app_timer/: app_timer.c app_timer.h
  group gr5515-sk/library/log
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/libraries/app_log/: app_log.c app_log.h
  group gr5515-sk/library/error
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/libraries/app_error/: app_error.c app_error.h app_error_cfg.h
  group gr5515-sk/library/assert
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/libraries/app_assert/: app_assert.c app_assert.h
  group gr5515-sk/library/pmu_calibration
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/libraries/pmu_calibration/: pmu_calibration.c pmu_calibration.h
  group gr5515-sk/library/ring_buffer
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/libraries/ring_buffer/: ring_buffer.c ring_buffer.h
  group gr5515-sk/library/utility
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/components/libraries/utility/: utility.c utility.h
  group gr5515-sk/segger_rtt
    ../../../../../vendors/goodix/GR551x_SDK_V1_00/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group gr5515-sk/ports/posix
    ../../../../../vendors/goodix/boards/GR5515-SK/ports/posix/: FreeRTOS_POSIX_portable.h
  group gr5515-sk/ports/pkcs11
    ../../../../../vendors/goodix/boards/GR5515-SK/ports/pkcs11/: iot_pkcs11_pal.c
  group gr5515-sk/ports/ble
    ../../../../../vendors/goodix/boards/GR5515-SK/ports/ble/: iot_ble_gap_config.h iot_ble_hal_common_gap.c iot_ble_hal_gap.c iot_ble_hal_gatt_server.c iot_ble_hal_internals.h gr_utils.c gr_utils.h gr_porting.c gr_porting.h gr_message.c gr_message.h gr_debug.c gr_debug.h gr_config.h
  group gr5515-sk/ports/ble/callback
    ../../../../../vendors/goodix/boards/GR5515-SK/ports/ble/user_callback/: user_app.h user_gap_callback.c user_gatt_common_callback.c user_gattc_callback.c user_l2cap_callback.c user_sm_callback.c gatts_profile_callback.c
  group gr5515-sk/ports/ota
    ../../../../../vendors/goodix/boards/GR5515-SK/ports/ota/: aws_ota_pal.c aws_ota_pal_config.h gr_ota_porting.c gr_ota_pal.c
